Commit message: 03/09/2025

File: ir_desription/urdf/ur_gripper.urdf (robot description, URDF)
Before this commit: robot ur_gripper, 24 links, 23 joints
Joints:
- joint base_joint: origin xyz=0 0 0 rpy=0 0 0 -> xyz=4 -0.5 0 rpy=0 0 0
